Helmet+-+Professional+Class (Autodesk Fusion 360 design; units mm, degrees)
description: STEP AP214
part number: Bell Helmet with dowel
base_feature "Base Feature"